<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Communication_Imate_Uart_V1.ewp</path>
    </project>
    <batchBuild />
</workspace>
